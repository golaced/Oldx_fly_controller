# Keil uVision project UCOSII-3.uvprojx, settings and files
target UCOSII-3 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UCOSII-3 +hex
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\FWLIB\inc;..\HARDWARE\TOUCH;..\HARDWARE\BEEP;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\TPAD;..\MALLOC;..\HARDWARE\flash;..\HARDWARE\KF;..\HARDWARE\GPS;..\HARDWARE\UKF_OLDX;..\HARDWARE\UKF_BARO;..\HARDWARE\UKF_NAV;..\HARDWARE\AVOID;..\HARDWARE\AHRS;..\HARDWARE\kalman-clib-master;..\HARDWARE\IIC;..\HARDWARE\ATT_EKF
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../HARDWARE/IIC/: include.h datasheet.txt ucos_task.c error.c
    ./: main.c
    ../UCOSII/CONFIG/: os_cfg.h
  group SYSTEM
    ../HARDWARE/UKF_OLDX/: rt_nonfinite.c rtGetNaN.c rtGetInf.c
    ./: stm32f4xx_it.c system_stm32f4xx.c
    ../CORE/: startup_stm32f40_41xxx.s
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group FWLIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_flash.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_iwdg.c stm32f4xx_can.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group HARDWARE
    ../HARDWARE/IIC/: iic1.c led_fc.c flash.c time.c dma.c watch_dog.c Ano_OF.c
    ../HARDWARE/flash/: flash_w25.c
  group COMMUNICATION
    ../HARDWARE/GPS/: gps.c m100.c
    ../HARDWARE/IIC/: usart_fc.c wifi_ctrl.c uwb.c
  group MEMS
    ../HARDWARE/IIC/: LIS3MDL.c mpu6050.c fliter.c ultrasonic.c hml_sample.c flow.c
  group MATH&FUSION
    ../HARDWARE/IIC/: FastMath.c my_math.c cycle_cal_oldx.c
  group EKF&IMU
    ../HARDWARE/IIC/: imu.c imu_m.c oldx_ekf_imu2.c
  group UKF&POS
    ../HARDWARE/UKF_OLDX/: ukf_task.c nav_ukf.c
    ../HARDWARE/UKF_NAV/: KF_OLDX_NAV.c
    ../HARDWARE/IIC/: alt_kf.c
