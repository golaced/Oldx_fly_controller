# Keil uVision project F407_FC.uvprojx, settings and files
target OLD-X FC 2.0 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F407_FC +hex
  AfterMake: fromelf --bin !L --output TEST.ANO
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,ARM_MATH_CM4,__CC_ARM
  c misc: --c99
  c include: .\applications;.\build;.\drivers;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\USBStack\INC;.\Libraries\FatFS\src;.\DSP_LIB\Include;.\MAVLINK;.\MAVLINK\minimal
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group System
    ./applications/: include.h main.c scheduler.c init.c parameter.c fly_mode.c stm32f4xx_it.c
  group Drivers
    ./drivers/: pwm_out.c led.c time.c
    ./applications/: flash.c flash_w25.c nrf.c spi.c rc_mine.c beep.c bat.c rng.c sbus_oldx.lib
  group Libraries
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_rng.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Math&Fushion
    ./applications/: imu.c alt_fushion.c anotc_baro_ctrl.c mymath.c baro_ekf_oldx.lib KF_OLDX_NAV.c filter.c quar.c rt_nonfinite.c rtGetInf.c rtGetNaN.c
  group Control
    ./applications/: pos_ctrl.c ctrl.c height_ctrl.c eso.c
  group Communication
    ./drivers/: usart.c
    ./applications/: rc.c dma.c m100.c
  group Sensor
    ./applications/: icm20602.c ms5611_spi.c
    ./drivers/: mpu6050.c ak8975.c ultrasonic.c
  group Mavlink
    ./drivers/: mavl.c
    ./MAVLINK/: checksum.c protocol.c mavlink_helpers.c fifo.c
    ./MAVLINK/minimal/: mavlink_msg_ahrs.c mavlink_msg_attitude.c mavlink_msg_global_position_int.c mavlink_msg_gps_raw_int.c mavlink_msg_gps_status.c mavlink_msg_heartbeat.c mavlink_msg_hwstatus.c mavlink_msg_limits_status.c mavlink_msg_meminfo.c mavlink_msg_mission_current.c mavlink_msg_mission_request.c mavlink_msg_nav_controller_output.c mavlink_msg_param_value.c mavlink_msg_raw_imu.c mavlink_msg_rc_channels_raw.c mavlink_msg_rc_channels_scaled.c mavlink_msg_sensor_offsets.c mavlink_msg_servo_output_raw.c mavlink_msg_simstate.c mavlink_msg_statustext.c mavlink_msg_sys_status.c mavlink_msg_vfr_hud.c testsuite.c
  group API
    ./drivers/: oldx_api.c oldx_mission.c
software components: CMSIS:CORE 4.3.0
